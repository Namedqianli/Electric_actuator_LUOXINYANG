# Keil uVision project remote.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: remote +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\nrf24l01;.\key
  group App
    ./: STARTUP.A51 main.c
  group BSP
    ./nrf24l01/: nrf24l01.c
    ./key/: key.c
